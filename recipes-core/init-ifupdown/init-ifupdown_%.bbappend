FILESEXTRAPATHS_prepend := "${THISDIR}/${MACHINE}:"
