PACKAGECONFIG_append = " tftp"
