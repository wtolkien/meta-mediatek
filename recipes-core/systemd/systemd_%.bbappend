FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
    file://0100-fix-emmc-dissect-image.patch \
    "
