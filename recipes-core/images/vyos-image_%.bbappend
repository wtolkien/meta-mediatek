# get directory of this append file while in global context:
# required for eMMC image build to pick up scatter file and
# preloader file from this directory

MTK_EMMC_FILEDIR_mt7623-evb := "${THISDIR}"
MTK_EMMC_FILEDIR_mt7623-bpi-r2 := "${THISDIR}"
